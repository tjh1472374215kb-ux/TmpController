# Keil uVision project TmpController.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32M67xx32NB Cmsemicon
  pack: Cmsemicon.CMS32M67xx.0.1.8
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TmpController +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CmsDevice\CMSIS;..\CmsDevice;..\CmsDriver;..\AppSource
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CmsDevice
    ../CmsDevice/: system_CMS32M67xx.c startup_CMS32M67xx.s
  group CmsDriver
    ../CmsDriver/: drvForADC.c drvForCCP.c drvForFMC.c drvForGpio.c drvForMain.c drvForPanel.c drvForUart.c drvForLHA.c
  group AppSource
    ../AppSource/: MappMain.c MappCode.c MappMenu.c MappShow.c MappComm.c McFuncPid.c MCtrlOutp.c MCtrlMain.c MCtrlTemp.c MCtrlRxIN.c MCtrlXnIN.c MCtrlWarn.c
